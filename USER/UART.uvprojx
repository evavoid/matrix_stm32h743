# Keil uVision project UART.uvprojx, settings and files
target UART (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --c99
  c include: ..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32H7xx_HAL_Driver\Inc;..\HARDWARE\LED;..\HARDWARE\KEY;..\DSPLIB\Include;..\HARDWARE\LCD;..\HARDWARE;..\SYSTEM\matrixos;..\HARDWARE\RNG;..\HARDWARE\SDRAM;..\HARDWARE\ZLG7290;..\HARDWARE\OLEDIIC;..\HARDWARE\ADS1256;..\HARDWARE\INNERADC;..\HARDWARE\IAP;..\DSPLIB\DSP_EXTERN_LIB;..\USMART;..\HARDWARE\NRF24L01;..\HARDWARE\HMC830;..\HARDWARE\ROLL;..\HARDWARE\UARTLCD;..\HARDWARE\FPGA_SPI;..\HARDWARE\MPU;..\HARDWARE\EXTI;..\HARDWARE\MALLOC;..\CENTER;..\HARDWARE\AD9959;..\HARDWARE\AD8302;..\HARDWARE\OLEDSPI;..\HARDWARE\AD9957_EVAL;..\HARDWARE\TJC_USARTLCD;..\HARDWARE\ADS1274;..\HARDWARE\ADF4351;..\HARDWARE\RTC;..\HARDWARE\UARTETH;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group USER
    ./: main.c stm32h7xx_it.c system_stm32h7xx.c stm32h7xx_hal_msp.c
  group CORE
    ../CORE/: core_cm7.h cmsis_armcc.h cmsis_compiler.h startup_stm32h743xx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/matrixos/: matrix_core.c globalspace.c
  group HALLIB
    ../HALLIB/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_hal_rng.c stm32h7xx_hal_sdram.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/RNG/: rng.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/ADS1256/: ads1256.c
    ../HARDWARE/ZLG7290/: zlg7290.c
    ../HARDWARE/INNERADC/: inneradc.c
    ../HARDWARE/IAP/: iap.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/HMC830/: hmc830.c
    ../HARDWARE/ROLL/: roll.c
    ../HARDWARE/UARTLCD/: uartlcd.c
    ../HARDWARE/FPGA_SPI/: fpga_spi.c
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/AD9959/: ad9959.c
    ../HARDWARE/AD8302/: ad8302.c
    ../HARDWARE/OLEDSPI/: oledspi.c
    ../HARDWARE/AD9957_EVAL/: ad9957_eval.c
    ../HARDWARE/ATK_ESP8266/: atkesp_apsta.c atkesp_wifiap.c atkesp_wifista.c atkesp8266.c
    ../HARDWARE/TJC_USARTLCD/: tjc_usartlcd.c
    ../HARDWARE/ADS1274/: ads1274.c
    ../HARDWARE/ADF4351/: adf4351.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/UARTETH/: uarteth.c
    ../HARDWARE/OLEDIIC/: olediic.c
  group README
    ./: readme.txt
  group DSPLIB
    ../DSPLIB/: arm_cortexM7lfdp_math.lib
    ../DSPLIB/DSP_EXTERN_LIB/: dsp_filter.c basic_calculation.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group CENTER
    ../CENTER/: center.c
software components: Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0
